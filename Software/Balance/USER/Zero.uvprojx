# Keil uVision project Zero.uvprojx, settings and files
target Zero (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Zero
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\APP\eMPL;..\APP;..\BSP;..\Core;..\FWLIB\inc;..\FWLIB\src;..\USER
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CORE
    ../Core/: core_cm3.c startup_stm32f10x_md.s
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c stm32f10x_conf.h
  group BSP
    ../BSP/: include.h led.c oled.c time.c usart1.c usart3.c delay.c motor.c encoder.c IOI2C.c adc.c spi.c
  group APP
    ./: config.h
    ../APP/: keep.c message.c IMU.c
    ../APP/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
  group FWLIB
    ../FWLIB/src/: misc.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c
